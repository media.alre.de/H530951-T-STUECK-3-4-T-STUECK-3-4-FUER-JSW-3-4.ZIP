Properties of the parts of a building model (IFC2X3)

# File
Description: T-Stück 3/4" für JSW-3/4, Messing vernickelt, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H530951, T-Stück 3/4" für JSW-3/4, Messing vernickelt
In: Raum
Description: T-Stück 3/4" für Strömungswächter JSW-3/4, Messing vernickelt; Classification: EC010123 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H530951; ModelLabel: T-Stück 3/4"; GlobalTradeItemNumber: 4050528044815; ProductURL: https://alre.de/produkt_H530951
Pset_Specification - NominalLength: 0.05 m; NominalWidth: 0.046 m; NominalDepth: 0.032 m; NetWeight: 0.153
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: sonstige; Zubehör: yes; ETIM-Klasse: EC010123; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H530951.pdf
